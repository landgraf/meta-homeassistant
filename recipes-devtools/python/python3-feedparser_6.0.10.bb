inherit setuptools3
require python-feedparser.inc

SRC_URI[md5sum] = "45716da638688577c7b0587a0a839a21"
SRC_URI[sha256sum] = "27da485f4637ce7163cdeab13a80312b93b7d0c1b775bef4a47629a3110bca51"

