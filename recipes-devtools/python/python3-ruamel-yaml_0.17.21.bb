inherit setuptools3
require python-ruamel-yaml.inc
SRC_URI[md5sum] = "206bda0f33ab2c2f63777636200748b7"
SRC_URI[sha256sum] = "8b7ce697a2f212752a35c1ac414471dc16c424c9573be4926b56ff3f5d23b7af"
