LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/files/common-licenses/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit pypi setuptools3

SRC_URI[md5sum] = "ee02d16491f65be09ae21787885dfeb0"
SRC_URI[sha256sum] = "2fc175fb730b39ebaed5d95db178a6daeec1b802146b0116ed13e7629a1bff46"

